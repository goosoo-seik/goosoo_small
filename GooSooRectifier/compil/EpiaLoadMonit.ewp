# IAR project EpiaLoadMonit.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91SAM7X256 Atmel AT91SAM7X256
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: srcIAR\; ..\src\; ..\..\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: ..\..\
  XLINK.XclFile: resource\at91SAM7X256_FLASH.xcl
configuration RAM_Debug (ARM, debug)
  as the first configuration, except:
  AARM.AUserIncludes: srcIAR\; ..\src\; ..\..\
  XLINK.XclFile: resource\at91SAM7X256_RAM.xcl
configuration Debug (ARM)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group Resource
    resource/: at91SAM7X256_FLASH.xcl at91SAM7X256_RAM.xcl SAM7_FLASH.mac SAM7_RAM.mac
  group src
    ../src/: CSLab_font.c CSLab_Rectifier_ADC.c CSLab_Rectifier_common.h CSLab_Rectifier_debug.c CSLab_Rectifier_reset.c CSLab_Rectifier_EXTIO.c CSLab_Rectifier_FND.c CSLab_Rectifier_key.c CSLab_Rectifier_main.c CSLab_Rectifier_Main.h CSLab_Rectifier_menu.c CSLab_Rectifier_profi.c CSLab_Rectifier_rs485.c CSLab_SAM7_ADC.c CSLab_SAM7_ADE7758.c CSLab_SAM7_DS1302.c CSLab_SAM7_extirq.c CSLab_SAM7_FLASH.c CSLab_SAM7_LCD128x64.c CSLab_SAM7_lib.c CSLab_SAM7_timer.c CSLab_SAM7_Usart.c CSLab_SAM7_Usart1.c CSLab_SAM7_UsartD.c Font_GULIM_13.c main.c
  group srcIAR
    ../../include/: AT91SAM7X256.inc
    SrcIAR/: Cstartup.s79 Cstartup_SAM7.c project.h
